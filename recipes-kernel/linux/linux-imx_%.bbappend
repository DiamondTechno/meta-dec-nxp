SRC_URI = "git://github.com/DiamondTechno/linux-imx.git;protocol=https;branch=${SRCBRANCH}"
SRCBRANCH = "dec-lf-6.6.y-v2"
SRCREV = "d983c9cd88d2325cb478201478722281f9a28934"
