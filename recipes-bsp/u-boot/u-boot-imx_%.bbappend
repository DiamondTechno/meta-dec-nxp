SRC_URI = "git://github.com/DiamondTechno/u-boot-imx.git;protocol=https;branch=${SRCBRANCH}"
SRCBRANCH = "dec_lf_v2024.04-imx93"
SRCREV = "e6533d8152471775e0bab82d4f80249436332dcf"
